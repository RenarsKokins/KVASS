## sdkconfig.defaults
```kconfig
CONFIG_TINYUSB_CDC_ENABLED=y
CONFIG_TINYUSB_HID_COUNT=1
CFG_TUD_ENABLED=y
CFG_TUD_HID=y
```
